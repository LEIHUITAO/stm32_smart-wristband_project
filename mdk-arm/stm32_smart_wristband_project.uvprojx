# Keil uVision project stm32_smart_wristband_project.uvprojx, settings and files
target stm32f103c8t6-smart-wristband (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_smart_wristband_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\application;..\peripheral_driver\inc;..\source;..\ucosiii\uc-bsp;..\ucosiii\uc-config;..\ucosiii\uc-cpu;..\ucosiii\uc-cpu\ARM-Cortex-M3\RealView;..\ucosiii\uc-lib;..\ucosiii\uc-lib\Ports\ARM-Cortex-M3\RealView;..\ucosiii\uc-ucosiii\Source;..\ucosiii\uc-ucosiii\Ports\ARM-Cortex-M3\Generic\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group application
    ../application/: core_cm3.c main.c stm32f10x_it.c system_stm32f10x.c
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group peripheral_driver
    ../peripheral_driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uc-bsp
    ../ucosiii/uc-bsp/: bsp.c
  group uc-config
    ../ucosiii/uc-config/: os_app_hooks.c
  group uc-cpu
    ../ucosiii/uc-cpu/: cpu_core.c
    ../ucosiii/uc-cpu/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uc-lib
    ../ucosiii/uc-lib/: lib_ascii.c lib_math.c lib_str.c lib_mem.c
    ../ucosiii/uc-lib/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uc-ucosiii
    ../ucosiii/uc-ucosiii/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../ucosiii/uc-ucosiii/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s
